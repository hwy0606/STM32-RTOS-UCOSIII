# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\ADC;..\HARDWARE;..\HARDWARE\Brake;..\HARDWARE\Brake_Control;..\HARDWARE\Controller;..\HARDWARE\CRC_16;..\HARDWARE\DAC;..\HARDWARE\delay;..\HARDWARE\Encoder;..\HARDWARE\Filter;..\HARDWARE\GPIO;..\HARDWARE\LED;..\HARDWARE\Mechanical_Data;..\HARDWARE\Motor;..\HARDWARE\Motor_Control;..\HARDWARE\Omron_Counter;..\HARDWARE\PWM;..\HARDWARE\Task_Circle;..\HARDWARE\Task_Loop;..\HARDWARE\Task_Timer;..\HARDWARE\Test;..\HARDWARE\Usart1_DMA;..\HARDWARE\Usart2_DMA;..\UCOSIII\uC-CPU;..\UCOSIII\uCOS_PROBE;..\UCOSIII\uCOS_PROBE\cfg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c task.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/Brake/: brake.c
    ../HARDWARE/Brake_Control/: brake_control.c
    ../HARDWARE/Controller/: controller.c
    ../HARDWARE/CRC_16/: crc_16.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/Encoder/: encoder.c
    ../HARDWARE/Filter/: Filter.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Mechanical_Data/: Mechanical_Data.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/Motor_Control/: motor_control.c
    ../HARDWARE/Omron_Counter/: Omron_Counter.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Task_Circle/: Task_Circle.c
    ../HARDWARE/Task_Loop/: Task_Loop.c
    ../HARDWARE/Task_Timer/: Task_Timer.c
    ../HARDWARE/Test/: test.c
    ../HARDWARE/Usart1_DMA/: usart1_dma.c
    ../HARDWARE/Usart2_DMA/: usart2_dma.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII_PROBE
    ../UCOSIII/uCOS_PROBE/: probe_scope.c probe_scope.h
    ../UCOSIII/uCOS_PROBE/cfg/: probe_scope_cfg.h
